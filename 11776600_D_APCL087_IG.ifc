Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-11-15T07:31:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 15 07:31:16 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\a43cc865-a1da-403a-8af7-269be6ccddb9\98d7af7f-293f-4256-9525-26afb2175938\ifc * Database version: 5507 * Database creation date: Tue Nov 15 07:31:15 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 15 07:31:16 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 15 07:31:16 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11776600_D_APCL087_IG:59590087_D_11776600_APCL087_IG, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 59590087_D_11776600_APCL087_IG
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 59590087_D_11776600_APCL087_IG
Pset_BuildingElementProxyCommon - sets with these values: 2
